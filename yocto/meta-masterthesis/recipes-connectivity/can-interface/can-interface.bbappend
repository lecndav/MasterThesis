FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:${THISDIR}/files:"